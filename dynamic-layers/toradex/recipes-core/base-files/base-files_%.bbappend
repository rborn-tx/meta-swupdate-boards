# Add a mount point for the uboot VFAT partition
dirs755 += "/uboot"
